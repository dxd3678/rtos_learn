# Keil uVision project tinyOS.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: tinyOS
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=5 wLevel=3
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./Source/: main.c switch.c tinyOS.h tBitmap.c tLib.h tConfig.h tList.c app.c tCpu.c tTask.c tTime.c tEvent.c tSem.c tMBox.c tMemBlock.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.2.2
